# Keil uVision project AT32F403ARGT7_WorkBench.uvprojx, settings and files
target AT32F403ARGT7_WorkBench (6230000::V6.23::ARMCLANG)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32F403ARGT7_WorkBench +hex
  AfterMake: C:\Users\Administrator\Desktop\keil5_disp_size_bar.exe
  AfterMake: fromelf.exe --bin --output .\Listings\@L.bin !L
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: AT32F403ARGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\system;..\app;..\drive
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c wk_crc.c wk_debug.c wk_gpio.c wk_wdt.c iap.c wk_adc.c wk_tmr.c wk_dac.c wk_usart.c wk_dma.c
    ../drive/: userconfig.h
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wdt.c at32f403a_407_misc.c at32f403a_407_dac.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group system
    ../system/: tmt.c
  group app
    ../app/: PC_comm_handle.c beep_handle.c collect_data_handle.c ec11_handle.c flash_handle.c key_handle.c PS305D_handle.c lcd_handle.c work_handle.c PID_handle.c output_handle.c
  group drive
    ../drive/: at32_Usart.c util_queue.c beep.c EncoderEC11.c flash.c key.c TM1680.c adc_filter.c round_data.c
software components: CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.1, Utilities:perf_counter:Core 2.4.0
